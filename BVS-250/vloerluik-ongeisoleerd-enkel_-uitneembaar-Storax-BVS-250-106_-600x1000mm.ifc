Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 12ecfa85-eadc-41da-b4d0-ab0a000d7bfb.ifc
Time: 2026-08-11T13:26:24
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - BVS-250 106, 600x1000mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAEZ-9bYDAAAAs-oCAAV2SgAA2FMBAFJfAQCT7AIAA-wCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAEZ-9bYDAAAAs-oCAAV2SgAA2FMBAFJfAQCT7AIAA-wCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 52 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 735 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 1135 mm; serie: BVS-250; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: C250; type: 106; dagmaatbreedte: 1000 mm; omranding: staal; luik: staal
